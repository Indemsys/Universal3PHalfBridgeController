# IAR project MQX_benchmark.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FN2M0xxx18 Freescale MK66FN2M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550
  ICCARM.CCIncludePath2: ..\..\MQX_SRC\config; ..\..\MQX_SRC\mfs\source\include; ..\..\MQX_SRC\mqx\source\bsp\K66BLEZ1; ..\..\MQX_SRC\mqx\source\include; ..\..\MQX_SRC\mqx\source\io\adc\kadc; ..\..\MQX_SRC\mqx\source\io\adc; ..\..\MQX_SRC\mqx\source\io\can\flexcan; ..\..\MQX_SRC\mqx\source\io\cm; ..\..\MQX_SRC\mqx\source\io\debug; ..\..\MQX_SRC\mqx\source\io\dma; ..\..\MQX_SRC\mqx\source\io\enet\macnet; ..\..\MQX_SRC\mqx\source\io\enet\phy; ..\..\MQX_SRC\mqx\source\io\enet; ..\..\MQX_SRC\mqx\source\io\esdhc; ..\..\MQX_SRC\mqx\source\io\flashx\freescale; ..\..\MQX_SRC\mqx\source\io\flashx; ..\..\MQX_SRC\mqx\source\io\gpio\kgpio; ..\..\MQX_SRC\mqx\source\io\gpio; ..\..\MQX_SRC\mqx\source\io\hwtimer; ..\..\MQX_SRC\mqx\source\io\i2c\int; ..\..\MQX_SRC\mqx\source\io\i2c\polled; ..\..\MQX_SRC\mqx\source\io\i2c; ..\..\MQX_SRC\mqx\source\io\io_mem; ..\..\MQX_SRC\mqx\source\io\io_null; ..\..\MQX_SRC\mqx\source\io\lpm; ..\..\MQX_SRC\mqx\source\io\lwadc; ..\..\MQX_SRC\mqx\source\io\lwgpio; ..\..\MQX_SRC\mqx\source\io\pcb\mqxa; ..\..\MQX_SRC\mqx\source\io\pcb; ..\..\MQX_SRC\mqx\source\io\pccard; ..\..\MQX_SRC\mqx\source\io\pcflash; ..\..\MQX_SRC\mqx\source\io\pipe; ..\..\MQX_SRC\mqx\source\io\rtc; ..\..\MQX_SRC\mqx\source\io\sai\dma; ..\..\MQX_SRC\mqx\source\io\sai; ..\..\MQX_SRC\mqx\source\io\sdcard\sdcard_esdhc; ..\..\MQX_SRC\mqx\source\io\sdcard\sdcard_spi; ..\..\MQX_SRC\mqx\source\io\sdcard; ..\..\MQX_SRC\mqx\source\io\serial; ..\..\MQX_SRC\mqx\source\io\spi; ..\..\MQX_SRC\mqx\source\io\tchres; ..\..\MQX_SRC\mqx\source\io\tfs; ..\..\MQX_SRC\mqx\source\io\timer; ..\..\MQX_SRC\mqx\source\io\usb; ..\..\MQX_SRC\mqx\source\io\usb_dcd\int; ..\..\MQX_SRC\mqx\source\io\usb_dcd\polled; ..\..\MQX_SRC\mqx\source\io\usb_dcd; ..\..\MQX_SRC\mqx\source\psp\cortex_m\compiler\iar; ..\..\MQX_SRC\mqx\source\psp\cortex_m\core\M4; ..\..\MQX_SRC\mqx\source\psp\cortex_m\cpu; ..\..\MQX_SRC\mqx\source\psp\cortex_m; ..\..\MQX_SRC\mqx\source\tad; ..\..\MQX_SRC\rtcs\source\include; ..\..\MQX_SRC\shell\source\include; ..\..\MQX_SRC\usb\adapter; ..\..\MQX_SRC\usb\device\classes\audio; ..\..\MQX_SRC\usb\device\classes\cdc; ..\..\MQX_SRC\usb\device\classes\common; ..\..\MQX_SRC\usb\device\classes\composite; ..\..\MQX_SRC\usb\device\classes\hid; ..\..\MQX_SRC\usb\device\classes\msd; ..\..\MQX_SRC\usb\device\classes\phdc; ..\..\MQX_SRC\usb\device\controller\ehci; ..\..\MQX_SRC\usb\device\controller\khci; ..\..\MQX_SRC\usb\device\controller; ..\..\MQX_SRC\usb\device; ..\..\MQX_SRC\usb\hal; ..\..\MQX_SRC\usb\include; Application; Peripherial; RTT
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: MQX_benchmark.hex
  ILINK.IlinkOutputFile: MQX_benchmark.out
  ILINK.IlinkIcfFile: intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  group (top)
    ../../: MQX_LIBRARY_O3.a
  group MQX_benchmark/Application
    Application/: Debug_io.c Main.c TimeMan.c
  group MQX_benchmark/Peripherial
    Peripherial/: Init_Pins.c K66BLEZ1_DMA.c K66BLEZ1_INIT_SYS.c
  group MQX_benchmark/RTT
    RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
