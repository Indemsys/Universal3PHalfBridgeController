# IAR project MQX_LIBRARY.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CPU_MK66FN2M0VLQ18; CPU_MK65F18; USB_2VCOM
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: config; mfs\source\include; mqx\source\bsp\K66BLEZ1; mqx\source\include; mqx\source\io\adc\kadc; mqx\source\io\adc; mqx\source\io\can\flexcan; mqx\source\io\cm; mqx\source\io\debug; mqx\source\io\dma; mqx\source\io\enet\macnet; mqx\source\io\enet\phy; mqx\source\io\enet; mqx\source\io\esdhc; mqx\source\io\flashx\freescale; mqx\source\io\flashx; mqx\source\io\gpio\kgpio; mqx\source\io\gpio; mqx\source\io\hwtimer; mqx\source\io\i2c\int; mqx\source\io\i2c\polled; mqx\source\io\i2c; mqx\source\io\io_mem; mqx\source\io\io_null; mqx\source\io\lpm; mqx\source\io\lwadc; mqx\source\io\lwgpio; mqx\source\io\pcb\mqxa; mqx\source\io\pcb; mqx\source\io\pccard; mqx\source\io\pcflash; mqx\source\io\pipe; mqx\source\io\rtc; mqx\source\io\sai\dma; mqx\source\io\sai; mqx\source\io\sdcard\sdcard_esdhc; mqx\source\io\sdcard\sdcard_spi; mqx\source\io\sdcard; mqx\source\io\serial; mqx\source\io\spi; mqx\source\io\tchres; mqx\source\io\tfs; mqx\source\io\timer; mqx\source\io\usb; mqx\source\io\usb_dcd\int; mqx\source\io\usb_dcd\polled; mqx\source\io\usb_dcd; mqx\source\psp\cortex_m\compiler\iar; mqx\source\psp\cortex_m\core\M4; mqx\source\psp\cortex_m\cpu; mqx\source\psp\cortex_m; mqx\source\tad; rtcs\source\include; shell\source\include; usb\adapter; usb\device\classes\audio; usb\device\classes\cdc; usb\device\classes\common; usb\device\classes\composite; usb\device\classes\hid; usb\device\classes\msd; usb\device\classes\phdc; usb\device\controller\ehci; usb\device\controller\khci; usb\device\controller; usb\device; usb\hal; usb\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: MQX_LIBRARY.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK66FN2M0VLQ18; CPU_MK65F18; USB_2VCOM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group MQX_SRC/mfs/source/generic
    mfs/source/generic/: dir_read.c mfs_attribute.c mfs_cache.c mfs_chain.c mfs_cluster.c mfs_delete.c mfs_dir_chain.c mfs_dir_entry.c mfs_directory.c mfs_fat.c mfs_find.c mfs_fio.c mfs_flush.c mfs_format.c mfs_globals.c mfs_handle.c mfs_ioctl.c mfs_lfn.c mfs_misc.c mfs_mount.c mfs_open.c mfs_parse.c mfs_read.c mfs_rename.c mfs_rw.c mfs_search.c mfs_time.c mfs_unicode.c mfs_valdev.c mfs_write.c part_mgr.c
  group MQX_SRC/mqx/source/bsp/K66BLEZ1
    mqx/source/bsp/K66BLEZ1/: bsp_cm.c init_adc.c init_bsp.c init_dma.c init_enet.c init_esdhc.c init_flashx.c init_gpio.c init_hw.c init_i2c.c init_iodebug.c init_lpm.c init_lwadc.c init_sai.c init_sci.c init_sdcard.c init_spi.c init_usb.c init_usb_dcd.c mqx_init.c mqx_main.c Sdelay.s vectors.c
  group MQX_SRC/mqx/source/fio
    mqx/source/fio/: io_clre.c io_dopr.c io_fclos.c io_feof.c io_ferr.c io_fflsh.c io_fgetc.c io_fgetl.c io_fgets.c io_fopen.c io_fp.c io_fprt.c io_fputc.c io_fputs.c io_fscan.c io_fseek.c io_fstat.c io_ftell.c io_fung.c io_ioctl.c io_misc.c io_pntf.c io_read.c io_scanf.c io_scanl.c io_spr.c io_sscan.c io_util.c io_vpr.c io_write.c
  group MQX_SRC/mqx/source/io
    mqx/source/io/: io_ghand.c io_init.c io_inst.c io_instx.c io_shand.c io_uinst.c
  group MQX_SRC/mqx/source/io/adc
    mqx/source/io/adc/: adc.c
  group MQX_SRC/mqx/source/io/adc/kadc
    mqx/source/io/adc/kadc/: adc_kadc.c adc_mk65.c adt_kpdb.c
  group MQX_SRC/mqx/source/io/can/flexcan
    mqx/source/io/can/flexcan/: fsl_flexcan_driver.c fsl_flexcan_hal.c fsl_flexcan_int.c
  group MQX_SRC/mqx/source/io/cm
    mqx/source/io/cm/: cm.c
  group MQX_SRC/mqx/source/io/debug
    mqx/source/io/debug/: iodebug.c iodebug_asm.s
  group MQX_SRC/mqx/source/io/dma
    mqx/source/io/dma/: dma.c edma.c edma_kinetisf.c
  group MQX_SRC/mqx/source/io/enet
    mqx/source/io/enet/: enaddr.c enclose.c enerr.c eninit.c enjoin.c enleave.c enmediactl.c enopen.c enrecv.c ensend.c enstat.c enstop.c enutil.c
  group MQX_SRC/mqx/source/io/enet/macnet
    mqx/source/io/enet/macnet/: macnet_1588.c macnet_init.c macnet_join.c macnet_mii.c macnet_mk65.c macnet_receive.c macnet_rejoin.c macnet_send.c macnet_stop.c macnet_util.c
  group MQX_SRC/mqx/source/io/enet/phy
    mqx/source/io/enet/phy/: phy_ksz8041.c
  group MQX_SRC/mqx/source/io/esdhc
    mqx/source/io/esdhc/: esdhc.c esdhc_mk65.c
  group MQX_SRC/mqx/source/io/flashx
    mqx/source/io/flashx/: flashx.c
  group MQX_SRC/mqx/source/io/flashx/freescale
    mqx/source/io/flashx/freescale/: flash_ftfe.c flash_mk65.c
  group MQX_SRC/mqx/source/io/gpio
    mqx/source/io/gpio/: io_gpio.c
  group MQX_SRC/mqx/source/io/gpio/kgpio
    mqx/source/io/gpio/kgpio/: io_gpio_kgpio.c
  group MQX_SRC/mqx/source/io/hwtimer
    mqx/source/io/hwtimer/: hwtimer.c hwtimer_kinetis.c hwtimer_lpt.c hwtimer_pit.c hwtimer_systick.c
  group MQX_SRC/mqx/source/io/i2c
    mqx/source/io/i2c/: i2c_mk65.c
  group MQX_SRC/mqx/source/io/i2c/int
    mqx/source/io/i2c/int/: i2c_int.c i2c_int_ki2c.c
  group MQX_SRC/mqx/source/io/i2c/polled
    mqx/source/io/i2c/polled/: i2c_pol.c i2c_pol_ki2c.c
  group MQX_SRC/mqx/source/io/io_mem
    mqx/source/io/io_mem/: io_mem.c
  group MQX_SRC/mqx/source/io/io_null
    mqx/source/io/io_null/: io_null.c
  group MQX_SRC/mqx/source/io/lpm
    mqx/source/io/lpm/: lpm.c lpm_smc.c
  group MQX_SRC/mqx/source/io/lwadc
    mqx/source/io/lwadc/: lwadc_k65.c lwadc_kadc.c
  group MQX_SRC/mqx/source/io/lwgpio
    mqx/source/io/lwgpio/: lwgpio.c lwgpio_kgpio.c
  group MQX_SRC/mqx/source/io/pcb
    mqx/source/io/pcb/: io_pcb.c io_pcb2.c
  group MQX_SRC/mqx/source/io/pcb/mqxa
    mqx/source/io/pcb/mqxa/: pcb_mqxa.c
  group MQX_SRC/mqx/source/io/pccard
    mqx/source/io/pccard/: pccardflexbus.c
  group MQX_SRC/mqx/source/io/pcflash
    mqx/source/io/pcflash/: apcflash.c
  group MQX_SRC/mqx/source/io/pipe
    mqx/source/io/pipe/: io_pipe.c
  group MQX_SRC/mqx/source/io/rtc
    mqx/source/io/rtc/: krtc.c
  group MQX_SRC/mqx/source/io/sai
    mqx/source/io/sai/: sai_mk65.c
  group MQX_SRC/mqx/source/io/sai/dma
    mqx/source/io/sai/dma/: sai_dma.c sai_dma_ksai.c
  group MQX_SRC/mqx/source/io/sdcard
    mqx/source/io/sdcard/: sdcard.c
  group MQX_SRC/mqx/source/io/sdcard/sdcard_esdhc
    mqx/source/io/sdcard/sdcard_esdhc/: sdcard_esdhc.c
  group MQX_SRC/mqx/source/io/sdcard/sdcard_spi
    mqx/source/io/sdcard/sdcard_spi/: sdcard_spi.c
  group MQX_SRC/mqx/source/io/serial
    mqx/source/io/serial/: io_sinit.c serl_mk65.c
  group MQX_SRC/mqx/source/io/serial/dma
    mqx/source/io/serial/dma/: serl_dma_kuart.c
  group MQX_SRC/mqx/source/io/serial/int
    mqx/source/io/serial/int/: serl_int.c serl_int_kuart.c
  group MQX_SRC/mqx/source/io/serial/polled
    mqx/source/io/serial/polled/: serl_pol.c serl_pol_kuart.c
  group MQX_SRC/mqx/source/io/spi
    mqx/source/io/spi/: spi.c spi_dspi.c spi_dspi_common.c spi_dspi_dma.c spi_mk65.c
  group MQX_SRC/mqx/source/io/tchres
    mqx/source/io/tchres/: tchres.c
  group MQX_SRC/mqx/source/io/tfs
    mqx/source/io/tfs/: tfs.c
  group MQX_SRC/mqx/source/io/timer
    mqx/source/io/timer/: timer_kinetis.c timer_qpit.c
  group MQX_SRC/mqx/source/io/usb
    mqx/source/io/usb/: usb_install.c usb_mk65f.c usb_mk65f_device.c
  group MQX_SRC/mqx/source/io/usb_dcd
    mqx/source/io/usb_dcd/: usb_dcd_mk65.c
  group MQX_SRC/mqx/source/io/usb_dcd/int
    mqx/source/io/usb_dcd/int/: usb_dcd_int.c usb_dcd_int_kn.c
  group MQX_SRC/mqx/source/io/usb_dcd/polled
    mqx/source/io/usb_dcd/polled/: usb_dcd_pol.c usb_dcd_pol_kn.c
  group MQX_SRC/mqx/source/kernel
    mqx/source/kernel/: event.c idletask.c inittask.c int.c ipc.c klog.c log.c lwevent.c lwlog.c lwmem.c lwmsgq.c lwsem.c lwtimer.c mem.c mqx.c msg.c msgpool.c msgq.c mutex.c name.c partition.c queue.c sched.c sem.c task.c taskq.c time.c timer.c tlsf.c tlsf_adaptation.c watchdog.c
  group MQX_SRC/mqx/source/psp/cortex_m
    mqx/source/psp/cortex_m/: cortex.c int_gkis.c int_inst.c int_kisr.c int_pvta.c int_unx.c int_vtab.c int_xcpt.c ipsum.c k_assert.c kinetis_mpu.c mem_copy.c mem_zero.c nvic.c psp_dati.c psp_gelms.c psp_hoti.c psp_iinit.c psp_mat1.c psp_mat2.c psp_mat3.c psp_miti.c psp_msti.c psp_mstiq.c psp_nsti.c psp_psti.c psp_seti.c psp_supp.c psp_tiad.c psp_tida.c psp_tihr.c psp_timn.c psp_tims.c psp_tinm.c psp_tins.c psp_tiol.c psp_tipr.c psp_tips.c psp_tise.c psp_tisu.c psp_tius.c psp_tkti.c psp_usti.c sc_irdyq.c stack_bu.c stack_de.c stack_st.c
  group MQX_SRC/mqx/source/psp/cortex_m/compiler/iar
    mqx/source/psp/cortex_m/compiler/iar/: comp.c kernel_symbols.s
  group MQX_SRC/mqx/source/psp/cortex_m/core/M4
    mqx/source/psp/cortex_m/core/M4/: boot.s dispatch.s support.s
  group MQX_SRC/mqx/source/string
    mqx/source/string/: str_utos.c strnlen.c
  group MQX_SRC/mqx/source/tad
    mqx/source/tad/: tad.c
  group MQX_SRC/rtcs/source/apps
    rtcs/source/apps/: dhcpsrv.c dnscln.c echocln.c echosrv.c ftpc.c ftpc_cmd.c ftpclnt.c ftpsrv.c ftpsrv_cmd.c ftpsrv_cmd_file.c ftpsrv_cmd_transfer.c ftpsrv_msg.c ftpsrv_supp.c ftpsrv_task.c httpsrv.c httpsrv_script.c httpsrv_supp.c httpsrv_task.c httpsrv_ws.c httpsrv_ws_api.c llmnrsrv.c modem.c modem_supp.c rtcs_base64.c rtcs_sha1.c rtcs_smtp.c rtcs_ssl.c rtcs_utf8.c rtcs_util.c sntp.c sockio.c socknio.c telnetcln.c telnetcln_supp.c telnetcln_task.c telnetio.c telnetsrv.c telnetsrv_supp.c telnetsrv_task.c tftp_supp.c tftpcln.c tftpcln_supp.c tftpcln_task.c tftpsrv.c tftpsrv_supp.c tftpsrv_task.c
  group MQX_SRC/rtcs/source/if
    rtcs/source/if/: arpcmd.c getaddrinfo.c getnameinfo.c ifbootp.c ifdhcp.c ifppp.c ifstat.c iftraps.c iftunnel.c inet.c inet_ntop.c inet_pton.c ipcfg.c ipcfg6.c iwcfg.c ping.c ping6.c rtcs.c rtcs_hosts.c rtcs_if.c rtcscmd.c rtcsdela.c rtcsglob.c rtcsinit.c rtcslog0.c rtcslog1.c rtcsrand.c sock.c sock_close.c sock_dgram.c sock_options.c sock_select.c sock_stream.c sock_util.c soigmp.c soip.c solink.c
  group MQX_SRC/rtcs/source/media
    rtcs/source/media/: arp.c ip-e.c ipcp.c ipcpfsm.c proxyarp.c
  group MQX_SRC/rtcs/source/nat
    rtcs/source/nat/: alggen.c dnat.c ifdnat.c ifnat.c nat.c nat_apply.c natalg.c natdata.c natevent.c natftp.c nattftp.c sonat.c
  group MQX_SRC/rtcs/source/os/mqx
    rtcs/source/os/mqx/: rtcsdate.c rtcsmsec.c rtcsmsg.c rtcspart.c rtcssec.c rtcstask.c
  group MQX_SRC/rtcs/source/ppp
    rtcs/source/ppp/: ccp.c chap.c gen16.c genmd5.c lcp.c md5.c md5step.c pap.c pktrx.c pkttx.c ppp.c pppfsm.c pppglob.c ppphdlc.c
  group MQX_SRC/rtcs/source/snmp
    rtcs/source/snmp/: 1213.c mib.c mqxmib.c snmp.c trap_receivers.c traps.c
  group MQX_SRC/rtcs/source/tcpip
    rtcs/source/tcpip/: bootcomm.c bootinit.c bootp.c checksum.c checksum6.c dhcpclnt.c dhcputil.c icmp.c igmp.c igmputil.c ip.c ip_if.c ip_reasm.c iplocal.c ipradix.c iproute.c iptunnel.c iputil.c rip.c route.c rtcspcb.c tcp.c tcp_buf.c tcp_clos.c tcp_rcv.c tcp_send.c tcp_timer.c tcpip.c ticker.c udp.c
  group MQX_SRC/shell/source/mfs
    shell/source/mfs/: sh_cache.c sh_cd.c sh_compare.c sh_copy.c sh_create.c sh_del.c sh_df.c sh_di.c sh_dir.c sh_dirent.c sh_disect.c sh_flush.c sh_format.c sh_mkdir.c sh_pwd.c sh_read.c sh_readtest.c sh_rename.c sh_rmdir.c sh_type.c sh_write.c sh_writetest.c
  group MQX_SRC/shell/source/mqx
    shell/source/mqx/: sh_abort.c sh_kill.c sh_pause.c sh_tad.c
  group MQX_SRC/shell/source/rtcs
    shell/source/rtcs/: sh_arpdisp.c sh_clock.c sh_echo.c sh_echosrv.c sh_enet.c sh_ftpc.c sh_ftpsrv.c sh_gate.c sh_getname.c sh_getroute.c sh_ghbn.c sh_ipconfig.c sh_iwconfig.c sh_llmnrsrv.c sh_nat.c sh_nstat.c sh_ping.c sh_ppp.c sh_rtcs.c sh_sendto.c sh_smtp.c sh_snmpd.c sh_telnetcln.c sh_telnetsrv.c sh_tftpcln.c sh_tftpsrv.c
  group MQX_SRC/shell/source/shell
    shell/source/shell/: sh_cmdlist.c sh_exit.c sh_help.c sh_sh.c sh_util.c shell.c
  group MQX_SRC/usb/adapter
    usb/adapter/: adapter_mqx.c
  group MQX_SRC/usb/device
    usb/device/: usb_dev_bsp.c
  group MQX_SRC/usb/device/classes/audio
    usb/device/classes/audio/: usb_audio.c
  group MQX_SRC/usb/device/classes/cdc
    usb/device/classes/cdc/: usb_cdc.c usb_cdc_pstn.c
  group MQX_SRC/usb/device/classes/common
    usb/device/classes/common/: usb_class.c
  group MQX_SRC/usb/device/classes/composite
    usb/device/classes/composite/: usb_composite.c
  group MQX_SRC/usb/device/classes/hid
    usb/device/classes/hid/: usb_hid.c
  group MQX_SRC/usb/device/classes/msd
    usb/device/classes/msd/: usb_msc.c usb_msc_scsi.c
  group MQX_SRC/usb/device/classes/phdc
    usb/device/classes/phdc/: usb_phdc.c
  group MQX_SRC/usb/device/controller
    usb/device/controller/: usb_dev.c usb_framework.c
  group MQX_SRC/usb/device/controller/ehci
    usb/device/controller/ehci/: device_ehci_interface.c ehci_dev_main.c
  group MQX_SRC/usb/device/controller/khci
    usb/device/controller/khci/: device_khci_interface.c khci_dev.c
