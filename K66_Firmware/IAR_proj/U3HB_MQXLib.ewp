# IAR project U3HB_MQXLib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FX1M0xxx18 NXP MK66FX1M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DEBUG=1; CPU_MK66FN2M0VLQ18; CPU_MK65F18; U3HB01_APP; USB_2VCOM
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550
  ICCARM.CCIncludePath2: ..\APP_SRC\FreeMaster; ..\APP_SRC\Matlab_PID_alg; ..\APP_SRC\MFS; ..\APP_SRC\Peripherial; ..\APP_SRC\RTT; ..\APP_SRC\U3HB01_app; ..\APP_SRC\USB_2VCOM; ..\APP_SRC\USB_commn; ..\APP_SRC\VT100; ..\APP_SRC; ..\MQX_SRC\config; ..\MQX_SRC\mfs\source\include; ..\MQX_SRC\mqx\source\bsp\K66BLEZ1; ..\MQX_SRC\mqx\source\include; ..\MQX_SRC\mqx\source\io\adc\kadc; ..\MQX_SRC\mqx\source\io\adc; ..\MQX_SRC\mqx\source\io\can\flexcan; ..\MQX_SRC\mqx\source\io\cm; ..\MQX_SRC\mqx\source\io\debug; ..\MQX_SRC\mqx\source\io\dma; ..\MQX_SRC\mqx\source\io\enet\macnet; ..\MQX_SRC\mqx\source\io\enet\phy; ..\MQX_SRC\mqx\source\io\enet; ..\MQX_SRC\mqx\source\io\esdhc; ..\MQX_SRC\mqx\source\io\flashx\freescale; ..\MQX_SRC\mqx\source\io\flashx; ..\MQX_SRC\mqx\source\io\gpio\kgpio; ..\MQX_SRC\mqx\source\io\gpio; ..\MQX_SRC\mqx\source\io\hwtimer; ..\MQX_SRC\mqx\source\io\i2c\int; ..\MQX_SRC\mqx\source\io\i2c\polled; ..\MQX_SRC\mqx\source\io\i2c; ..\MQX_SRC\mqx\source\io\io_mem; ..\MQX_SRC\mqx\source\io\io_null; ..\MQX_SRC\mqx\source\io\lpm; ..\MQX_SRC\mqx\source\io\lwadc; ..\MQX_SRC\mqx\source\io\lwgpio; ..\MQX_SRC\mqx\source\io\pcb\mqxa; ..\MQX_SRC\mqx\source\io\pcb; ..\MQX_SRC\mqx\source\io\pccard; ..\MQX_SRC\mqx\source\io\pcflash; ..\MQX_SRC\mqx\source\io\pipe; ..\MQX_SRC\mqx\source\io\rtc; ..\MQX_SRC\mqx\source\io\sai\dma; ..\MQX_SRC\mqx\source\io\sai; ..\MQX_SRC\mqx\source\io\sdcard\sdcard_esdhc; ..\MQX_SRC\mqx\source\io\sdcard\sdcard_spi; ..\MQX_SRC\mqx\source\io\sdcard; ..\MQX_SRC\mqx\source\io\serial; ..\MQX_SRC\mqx\source\io\spi; ..\MQX_SRC\mqx\source\io\tchres; ..\MQX_SRC\mqx\source\io\tfs; ..\MQX_SRC\mqx\source\io\timer; ..\MQX_SRC\mqx\source\io\usb; ..\MQX_SRC\mqx\source\io\usb_dcd\int; ..\MQX_SRC\mqx\source\io\usb_dcd\polled; ..\MQX_SRC\mqx\source\io\usb_dcd; ..\MQX_SRC\mqx\source\psp\cortex_m\compiler\iar; ..\MQX_SRC\mqx\source\psp\cortex_m\core\M4; ..\MQX_SRC\mqx\source\psp\cortex_m\cpu; ..\MQX_SRC\mqx\source\psp\cortex_m; ..\MQX_SRC\mqx\source\tad; ..\MQX_SRC\rtcs\source\include; ..\MQX_SRC\shell\source\include; ..\MQX_SRC\usb\adapter; ..\MQX_SRC\usb\device\classes\audio; ..\MQX_SRC\usb\device\classes\cdc; ..\MQX_SRC\usb\device\classes\common; ..\MQX_SRC\usb\device\classes\composite; ..\MQX_SRC\usb\device\classes\hid; ..\MQX_SRC\usb\device\classes\msd; ..\MQX_SRC\usb\device\classes\phdc; ..\MQX_SRC\usb\device\controller\ehci; ..\MQX_SRC\usb\device\controller\khci; ..\MQX_SRC\usb\device\controller; ..\MQX_SRC\usb\device; ..\MQX_SRC\usb\hal; ..\MQX_SRC\usb\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: U3HB_MQXLib.hex
  ILINK.IlinkOutputFile: U3HB_MQXLib.out
  ILINK.IlinkKeepSymbols: __checksum
  ILINK.IlinkIcfFile: INT_FLASH_MK66FX1M0LVQ18.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group (top)
    ../: MQX_LIBRARY_O3.a
  group APP_SRC
    ../APP_SRC/: App_logger.c CAN_IO_exchange.c CRC_utils.c Debug_io.c Filters.c FreeMaster_vars.c Inputs_processing.c LED_control.c Main.c MKW40_Channel.c Parameters.c QuadDecoder.c RTOS_utils.c Supervisor_task.c TimeMan.c U3HB01_Params.c WatchDogCtrl.c
  group APP_SRC/FreeMaster
    ../APP_SRC/FreeMaster/: freemaster_appcmd.c freemaster_os.c freemaster_pipes.c freemaster_protocol.c freemaster_rec.c freemaster_scope.c freemaster_serial.c freemaster_sfio.c freemaster_tsa.c Task_FreeMaster.c
  group APP_SRC/Matlab_PID_alg
    ../APP_SRC/Matlab_PID_alg/: PIDController.c
  group APP_SRC/MFS
    ../APP_SRC/MFS/: MFS_man.c MFS_Shell.c
  group APP_SRC/Peripherial
    ../APP_SRC/Peripherial/: Init_Pins.c K66BLEZ1_ADC.c K66BLEZ1_CAN.c K66BLEZ1_DAC.c K66BLEZ1_DMA.c K66BLEZ1_FTM.c K66BLEZ1_INIT_SYS.c K66BLEZ1_MKW40_Channel.c K66BLEZ1_PIT.c K66BLEZ1_SPI.c K66BLEZ1_VBAT_RAM.c
  group APP_SRC/RTT
    ../APP_SRC/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group APP_SRC/U3HB01_app
    ../APP_SRC/U3HB01_app/: U3HB01_BLDC.c U3HB01_CAN.c U3HB01_DRV8305.c U3HB01_ExtEncoder.c U3HB01_FreemasterCmdMan.c U3HB01_Hall_BLDC.c U3HB01_Hall_sensor.c U3HB01_main.c U3HB01_monitor.c U3HB01_PIDcontrol.c U3HB01_Pins.c U3HB01_RotationControl.c U3HB01_sensless_BLDC.c U3HB01_SolenoidControl.c U3HB01_SPISysBus.c U3HB01_WS2812B.c
  group APP_SRC/USB_2VCOM
    ../APP_SRC/USB_2VCOM/: USB_composite_dev.c usb_device_descriptor.c USB_virtual_com1.c USB_virtual_com2.c
  group APP_SRC/USB_commn
    ../APP_SRC/USB_commn/: USB_debug.c
  group APP_SRC/VT100
    ../APP_SRC/VT100/: MFS_test.c Monitor_serial_drv.c Monitor_usb_drv.c MonitorVT100.c
