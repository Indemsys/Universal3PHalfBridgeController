<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\U3HB_MQXLib.ewp</path>
  </project>
  <batchBuild/>
</workspace>


