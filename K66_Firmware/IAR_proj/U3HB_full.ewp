# IAR project U3HB_full.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FX1M0xxx18 NXP MK66FX1M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DEBUG=1; CPU_MK66FN2M0VLQ18; CPU_MK65F18; U3HB01_APP; USB_2VCOM
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550
  ICCARM.CCIncludePath2: ..\APP_SRC\FreeMaster; ..\APP_SRC\Matlab_PID_alg; ..\APP_SRC\MFS; ..\APP_SRC\Peripherial; ..\APP_SRC\RTT; ..\APP_SRC\U3HB01_app; ..\APP_SRC\USB_2VCOM; ..\APP_SRC\USB_commn; ..\APP_SRC\VT100; ..\APP_SRC; ..\MQX_SRC\config; ..\MQX_SRC\mfs\source\include; ..\MQX_SRC\mqx\source\bsp\K66BLEZ1; ..\MQX_SRC\mqx\source\include; ..\MQX_SRC\mqx\source\io\adc\kadc; ..\MQX_SRC\mqx\source\io\adc; ..\MQX_SRC\mqx\source\io\can\flexcan; ..\MQX_SRC\mqx\source\io\cm; ..\MQX_SRC\mqx\source\io\debug; ..\MQX_SRC\mqx\source\io\dma; ..\MQX_SRC\mqx\source\io\enet\macnet; ..\MQX_SRC\mqx\source\io\enet\phy; ..\MQX_SRC\mqx\source\io\enet; ..\MQX_SRC\mqx\source\io\esdhc; ..\MQX_SRC\mqx\source\io\flashx\freescale; ..\MQX_SRC\mqx\source\io\flashx; ..\MQX_SRC\mqx\source\io\gpio\kgpio; ..\MQX_SRC\mqx\source\io\gpio; ..\MQX_SRC\mqx\source\io\hwtimer; ..\MQX_SRC\mqx\source\io\i2c\int; ..\MQX_SRC\mqx\source\io\i2c\polled; ..\MQX_SRC\mqx\source\io\i2c; ..\MQX_SRC\mqx\source\io\io_mem; ..\MQX_SRC\mqx\source\io\io_null; ..\MQX_SRC\mqx\source\io\lpm; ..\MQX_SRC\mqx\source\io\lwadc; ..\MQX_SRC\mqx\source\io\lwgpio; ..\MQX_SRC\mqx\source\io\pcb\mqxa; ..\MQX_SRC\mqx\source\io\pcb; ..\MQX_SRC\mqx\source\io\pccard; ..\MQX_SRC\mqx\source\io\pcflash; ..\MQX_SRC\mqx\source\io\pipe; ..\MQX_SRC\mqx\source\io\rtc; ..\MQX_SRC\mqx\source\io\sai\dma; ..\MQX_SRC\mqx\source\io\sai; ..\MQX_SRC\mqx\source\io\sdcard\sdcard_esdhc; ..\MQX_SRC\mqx\source\io\sdcard\sdcard_spi; ..\MQX_SRC\mqx\source\io\sdcard; ..\MQX_SRC\mqx\source\io\serial; ..\MQX_SRC\mqx\source\io\spi; ..\MQX_SRC\mqx\source\io\tchres; ..\MQX_SRC\mqx\source\io\tfs; ..\MQX_SRC\mqx\source\io\timer; ..\MQX_SRC\mqx\source\io\usb; ..\MQX_SRC\mqx\source\io\usb_dcd\int; ..\MQX_SRC\mqx\source\io\usb_dcd\polled; ..\MQX_SRC\mqx\source\io\usb_dcd; ..\MQX_SRC\mqx\source\psp\cortex_m\compiler\iar; ..\MQX_SRC\mqx\source\psp\cortex_m\core\M4; ..\MQX_SRC\mqx\source\psp\cortex_m\cpu; ..\MQX_SRC\mqx\source\psp\cortex_m; ..\MQX_SRC\mqx\source\tad; ..\MQX_SRC\rtcs\source\include; ..\MQX_SRC\shell\source\include; ..\MQX_SRC\usb\adapter; ..\MQX_SRC\usb\device\classes\audio; ..\MQX_SRC\usb\device\classes\cdc; ..\MQX_SRC\usb\device\classes\common; ..\MQX_SRC\usb\device\classes\composite; ..\MQX_SRC\usb\device\classes\hid; ..\MQX_SRC\usb\device\classes\msd; ..\MQX_SRC\usb\device\classes\phdc; ..\MQX_SRC\usb\device\controller\ehci; ..\MQX_SRC\usb\device\controller\khci; ..\MQX_SRC\usb\device\controller; ..\MQX_SRC\usb\device; ..\MQX_SRC\usb\hal; ..\MQX_SRC\usb\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: U3HB_full.hex
  ILINK.IlinkOutputFile: U3HB_full.out
  ILINK.IlinkKeepSymbols: __checksum
  ILINK.IlinkIcfFile: INT_FLASH_MK66FX1M0LVQ18.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP_SRC
    ../APP_SRC/: App_logger.c CAN_IO_exchange.c CRC_utils.c Debug_io.c Filters.c FreeMaster_vars.c Inputs_processing.c LED_control.c Main.c MKW40_Channel.c Parameters.c QuadDecoder.c RTOS_utils.c Supervisor_task.c TimeMan.c U3HB01_Params.c WatchDogCtrl.c
  group APP_SRC/FreeMaster
    ../APP_SRC/FreeMaster/: freemaster_appcmd.c freemaster_os.c freemaster_pipes.c freemaster_protocol.c freemaster_rec.c freemaster_scope.c freemaster_serial.c freemaster_sfio.c freemaster_tsa.c Task_FreeMaster.c
  group APP_SRC/Matlab_PID_alg
    ../APP_SRC/Matlab_PID_alg/: PIDController.c
  group APP_SRC/MFS
    ../APP_SRC/MFS/: MFS_man.c MFS_Shell.c
  group APP_SRC/Peripherial
    ../APP_SRC/Peripherial/: Init_Pins.c K66BLEZ1_ADC.c K66BLEZ1_CAN.c K66BLEZ1_DAC.c K66BLEZ1_DMA.c K66BLEZ1_FTM.c K66BLEZ1_INIT_SYS.c K66BLEZ1_MKW40_Channel.c K66BLEZ1_PIT.c K66BLEZ1_SPI.c K66BLEZ1_VBAT_RAM.c
  group APP_SRC/RTT
    ../APP_SRC/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group APP_SRC/U3HB01_app
    ../APP_SRC/U3HB01_app/: U3HB01_BLDC.c U3HB01_CAN.c U3HB01_DRV8305.c U3HB01_ExtEncoder.c U3HB01_FreemasterCmdMan.c U3HB01_Hall_BLDC.c U3HB01_Hall_sensor.c U3HB01_main.c U3HB01_monitor.c U3HB01_PIDcontrol.c U3HB01_Pins.c U3HB01_RotationControl.c U3HB01_sensless_BLDC.c U3HB01_SolenoidControl.c U3HB01_SPISysBus.c U3HB01_WS2812B.c
  group APP_SRC/USB_2VCOM
    ../APP_SRC/USB_2VCOM/: USB_composite_dev.c usb_device_descriptor.c USB_virtual_com1.c USB_virtual_com2.c
  group APP_SRC/USB_commn
    ../APP_SRC/USB_commn/: USB_debug.c
  group APP_SRC/VT100
    ../APP_SRC/VT100/: MFS_test.c Monitor_serial_drv.c Monitor_usb_drv.c MonitorVT100.c
  group MQX_SRC/mfs/source/generic
    ../MQX_SRC/mfs/source/generic/: dir_read.c mfs_attribute.c mfs_cache.c mfs_chain.c mfs_cluster.c mfs_delete.c mfs_dir_chain.c mfs_dir_entry.c mfs_directory.c mfs_fat.c mfs_find.c mfs_fio.c mfs_flush.c mfs_format.c mfs_globals.c mfs_handle.c mfs_ioctl.c mfs_lfn.c mfs_misc.c mfs_mount.c mfs_open.c mfs_parse.c mfs_read.c mfs_rename.c mfs_rw.c mfs_search.c mfs_time.c mfs_unicode.c mfs_valdev.c mfs_write.c part_mgr.c
  group MQX_SRC/mqx/source/bsp/K66BLEZ1
    ../MQX_SRC/mqx/source/bsp/K66BLEZ1/: bsp_cm.c init_adc.c init_bsp.c init_dma.c init_enet.c init_esdhc.c init_flashx.c init_gpio.c init_hw.c init_i2c.c init_iodebug.c init_lpm.c init_lwadc.c init_sai.c init_sci.c init_sdcard.c init_spi.c init_usb.c init_usb_dcd.c mqx_init.c mqx_main.c Sdelay.s vectors.c
  group MQX_SRC/mqx/source/fio
    ../MQX_SRC/mqx/source/fio/: io_clre.c io_dopr.c io_fclos.c io_feof.c io_ferr.c io_fflsh.c io_fgetc.c io_fgetl.c io_fgets.c io_fopen.c io_fp.c io_fprt.c io_fputc.c io_fputs.c io_fscan.c io_fseek.c io_fstat.c io_ftell.c io_fung.c io_ioctl.c io_misc.c io_pntf.c io_read.c io_scanf.c io_scanl.c io_spr.c io_sscan.c io_util.c io_vpr.c io_write.c
  group MQX_SRC/mqx/source/io
    ../MQX_SRC/mqx/source/io/: io_ghand.c io_init.c io_inst.c io_instx.c io_shand.c io_uinst.c
  group MQX_SRC/mqx/source/io/adc
    ../MQX_SRC/mqx/source/io/adc/: adc.c
  group MQX_SRC/mqx/source/io/adc/kadc
    ../MQX_SRC/mqx/source/io/adc/kadc/: adc_kadc.c adc_mk65.c adt_kpdb.c
  group MQX_SRC/mqx/source/io/can/flexcan
    ../MQX_SRC/mqx/source/io/can/flexcan/: fsl_flexcan_driver.c fsl_flexcan_hal.c fsl_flexcan_int.c
  group MQX_SRC/mqx/source/io/cm
    ../MQX_SRC/mqx/source/io/cm/: cm.c
  group MQX_SRC/mqx/source/io/debug
    ../MQX_SRC/mqx/source/io/debug/: iodebug.c iodebug_asm.s
  group MQX_SRC/mqx/source/io/dma
    ../MQX_SRC/mqx/source/io/dma/: dma.c edma.c edma_kinetisf.c
  group MQX_SRC/mqx/source/io/enet
    ../MQX_SRC/mqx/source/io/enet/: enaddr.c enclose.c enerr.c eninit.c enjoin.c enleave.c enmediactl.c enopen.c enrecv.c ensend.c enstat.c enstop.c enutil.c
  group MQX_SRC/mqx/source/io/enet/macnet
    ../MQX_SRC/mqx/source/io/enet/macnet/: macnet_1588.c macnet_init.c macnet_join.c macnet_mii.c macnet_mk65.c macnet_receive.c macnet_rejoin.c macnet_send.c macnet_stop.c macnet_util.c
  group MQX_SRC/mqx/source/io/enet/phy
    ../MQX_SRC/mqx/source/io/enet/phy/: phy_ksz8041.c
  group MQX_SRC/mqx/source/io/esdhc
    ../MQX_SRC/mqx/source/io/esdhc/: esdhc.c esdhc_mk65.c
  group MQX_SRC/mqx/source/io/flashx
    ../MQX_SRC/mqx/source/io/flashx/: flashx.c
  group MQX_SRC/mqx/source/io/flashx/freescale
    ../MQX_SRC/mqx/source/io/flashx/freescale/: flash_ftfe.c flash_mk65.c
  group MQX_SRC/mqx/source/io/gpio
    ../MQX_SRC/mqx/source/io/gpio/: io_gpio.c
  group MQX_SRC/mqx/source/io/gpio/kgpio
    ../MQX_SRC/mqx/source/io/gpio/kgpio/: io_gpio_kgpio.c
  group MQX_SRC/mqx/source/io/hwtimer
    ../MQX_SRC/mqx/source/io/hwtimer/: hwtimer.c hwtimer_kinetis.c hwtimer_lpt.c hwtimer_pit.c hwtimer_systick.c
  group MQX_SRC/mqx/source/io/i2c
    ../MQX_SRC/mqx/source/io/i2c/: i2c_mk65.c
  group MQX_SRC/mqx/source/io/i2c/int
    ../MQX_SRC/mqx/source/io/i2c/int/: i2c_int.c i2c_int_ki2c.c
  group MQX_SRC/mqx/source/io/i2c/polled
    ../MQX_SRC/mqx/source/io/i2c/polled/: i2c_pol.c i2c_pol_ki2c.c
  group MQX_SRC/mqx/source/io/io_mem
    ../MQX_SRC/mqx/source/io/io_mem/: io_mem.c
  group MQX_SRC/mqx/source/io/io_null
    ../MQX_SRC/mqx/source/io/io_null/: io_null.c
  group MQX_SRC/mqx/source/io/lpm
    ../MQX_SRC/mqx/source/io/lpm/: lpm.c lpm_smc.c
  group MQX_SRC/mqx/source/io/lwadc
    ../MQX_SRC/mqx/source/io/lwadc/: lwadc_k65.c lwadc_kadc.c
  group MQX_SRC/mqx/source/io/lwgpio
    ../MQX_SRC/mqx/source/io/lwgpio/: lwgpio.c lwgpio_kgpio.c
  group MQX_SRC/mqx/source/io/pcb
    ../MQX_SRC/mqx/source/io/pcb/: io_pcb.c io_pcb2.c
  group MQX_SRC/mqx/source/io/pcb/mqxa
    ../MQX_SRC/mqx/source/io/pcb/mqxa/: pcb_mqxa.c
  group MQX_SRC/mqx/source/io/pccard
    ../MQX_SRC/mqx/source/io/pccard/: pccardflexbus.c
  group MQX_SRC/mqx/source/io/pcflash
    ../MQX_SRC/mqx/source/io/pcflash/: apcflash.c
  group MQX_SRC/mqx/source/io/pipe
    ../MQX_SRC/mqx/source/io/pipe/: io_pipe.c
  group MQX_SRC/mqx/source/io/rtc
    ../MQX_SRC/mqx/source/io/rtc/: krtc.c
  group MQX_SRC/mqx/source/io/sai
    ../MQX_SRC/mqx/source/io/sai/: sai_mk65.c
  group MQX_SRC/mqx/source/io/sai/dma
    ../MQX_SRC/mqx/source/io/sai/dma/: sai_dma.c sai_dma_ksai.c
  group MQX_SRC/mqx/source/io/sdcard
    ../MQX_SRC/mqx/source/io/sdcard/: sdcard.c
  group MQX_SRC/mqx/source/io/sdcard/sdcard_esdhc
    ../MQX_SRC/mqx/source/io/sdcard/sdcard_esdhc/: sdcard_esdhc.c
  group MQX_SRC/mqx/source/io/sdcard/sdcard_spi
    ../MQX_SRC/mqx/source/io/sdcard/sdcard_spi/: sdcard_spi.c
  group MQX_SRC/mqx/source/io/serial
    ../MQX_SRC/mqx/source/io/serial/: io_sinit.c serl_mk65.c
  group MQX_SRC/mqx/source/io/serial/dma
    ../MQX_SRC/mqx/source/io/serial/dma/: serl_dma_kuart.c
  group MQX_SRC/mqx/source/io/serial/int
    ../MQX_SRC/mqx/source/io/serial/int/: serl_int.c serl_int_kuart.c
  group MQX_SRC/mqx/source/io/serial/polled
    ../MQX_SRC/mqx/source/io/serial/polled/: serl_pol.c serl_pol_kuart.c
  group MQX_SRC/mqx/source/io/spi
    ../MQX_SRC/mqx/source/io/spi/: spi.c spi_dspi.c spi_dspi_common.c spi_dspi_dma.c spi_mk65.c
  group MQX_SRC/mqx/source/io/tchres
    ../MQX_SRC/mqx/source/io/tchres/: tchres.c
  group MQX_SRC/mqx/source/io/tfs
    ../MQX_SRC/mqx/source/io/tfs/: tfs.c
  group MQX_SRC/mqx/source/io/timer
    ../MQX_SRC/mqx/source/io/timer/: timer_kinetis.c timer_qpit.c
  group MQX_SRC/mqx/source/io/usb
    ../MQX_SRC/mqx/source/io/usb/: usb_install.c usb_mk65f.c usb_mk65f_device.c
  group MQX_SRC/mqx/source/io/usb_dcd
    ../MQX_SRC/mqx/source/io/usb_dcd/: usb_dcd_mk65.c
  group MQX_SRC/mqx/source/io/usb_dcd/int
    ../MQX_SRC/mqx/source/io/usb_dcd/int/: usb_dcd_int.c usb_dcd_int_kn.c
  group MQX_SRC/mqx/source/io/usb_dcd/polled
    ../MQX_SRC/mqx/source/io/usb_dcd/polled/: usb_dcd_pol.c usb_dcd_pol_kn.c
  group MQX_SRC/mqx/source/kernel
    ../MQX_SRC/mqx/source/kernel/: event.c idletask.c inittask.c int.c ipc.c klog.c log.c lwevent.c lwlog.c lwmem.c lwmsgq.c lwsem.c lwtimer.c mem.c mqx.c msg.c msgpool.c msgq.c mutex.c name.c partition.c queue.c sched.c sem.c task.c taskq.c time.c timer.c tlsf.c tlsf_adaptation.c watchdog.c
  group MQX_SRC/mqx/source/psp/cortex_m
    ../MQX_SRC/mqx/source/psp/cortex_m/: cortex.c int_gkis.c int_inst.c int_kisr.c int_pvta.c int_unx.c int_vtab.c int_xcpt.c ipsum.c k_assert.c kinetis_mpu.c mem_copy.c mem_zero.c nvic.c psp_dati.c psp_gelms.c psp_hoti.c psp_iinit.c psp_mat1.c psp_mat2.c psp_mat3.c psp_miti.c psp_msti.c psp_mstiq.c psp_nsti.c psp_psti.c psp_seti.c psp_supp.c psp_tiad.c psp_tida.c psp_tihr.c psp_timn.c psp_tims.c psp_tinm.c psp_tins.c psp_tiol.c psp_tipr.c psp_tips.c psp_tise.c psp_tisu.c psp_tius.c psp_tkti.c psp_usti.c sc_irdyq.c stack_bu.c stack_de.c stack_st.c
  group MQX_SRC/mqx/source/psp/cortex_m/compiler/iar
    ../MQX_SRC/mqx/source/psp/cortex_m/compiler/iar/: comp.c kernel_symbols.s
  group MQX_SRC/mqx/source/psp/cortex_m/core/M4
    ../MQX_SRC/mqx/source/psp/cortex_m/core/M4/: boot.s dispatch.s support.s
  group MQX_SRC/mqx/source/string
    ../MQX_SRC/mqx/source/string/: str_utos.c strnlen.c
  group MQX_SRC/mqx/source/tad
    ../MQX_SRC/mqx/source/tad/: tad.c
  group MQX_SRC/rtcs/source/apps
    ../MQX_SRC/rtcs/source/apps/: dhcpsrv.c dnscln.c echocln.c echosrv.c ftpc.c ftpc_cmd.c ftpclnt.c ftpsrv.c ftpsrv_cmd.c ftpsrv_cmd_file.c ftpsrv_cmd_transfer.c ftpsrv_msg.c ftpsrv_supp.c ftpsrv_task.c httpsrv.c httpsrv_script.c httpsrv_supp.c httpsrv_task.c httpsrv_ws.c httpsrv_ws_api.c llmnrsrv.c modem.c modem_supp.c rtcs_base64.c rtcs_sha1.c rtcs_smtp.c rtcs_ssl.c rtcs_utf8.c rtcs_util.c sntp.c sockio.c socknio.c telnetcln.c telnetcln_supp.c telnetcln_task.c telnetio.c telnetsrv.c telnetsrv_supp.c telnetsrv_task.c tftp_supp.c tftpcln.c tftpcln_supp.c tftpcln_task.c tftpsrv.c tftpsrv_supp.c tftpsrv_task.c
  group MQX_SRC/rtcs/source/if
    ../MQX_SRC/rtcs/source/if/: arpcmd.c getaddrinfo.c getnameinfo.c ifbootp.c ifdhcp.c ifppp.c ifstat.c iftraps.c iftunnel.c inet.c inet_ntop.c inet_pton.c ipcfg.c ipcfg6.c iwcfg.c ping.c ping6.c rtcs.c rtcs_hosts.c rtcs_if.c rtcscmd.c rtcsdela.c rtcsglob.c rtcsinit.c rtcslog0.c rtcslog1.c rtcsrand.c sock.c sock_close.c sock_dgram.c sock_options.c sock_select.c sock_stream.c sock_util.c soigmp.c soip.c solink.c
  group MQX_SRC/rtcs/source/media
    ../MQX_SRC/rtcs/source/media/: arp.c ip-e.c ipcp.c ipcpfsm.c proxyarp.c
  group MQX_SRC/rtcs/source/nat
    ../MQX_SRC/rtcs/source/nat/: alggen.c dnat.c ifdnat.c ifnat.c nat.c nat_apply.c natalg.c natdata.c natevent.c natftp.c nattftp.c sonat.c
  group MQX_SRC/rtcs/source/os/mqx
    ../MQX_SRC/rtcs/source/os/mqx/: rtcsdate.c rtcsmsec.c rtcsmsg.c rtcspart.c rtcssec.c rtcstask.c
  group MQX_SRC/rtcs/source/ppp
    ../MQX_SRC/rtcs/source/ppp/: ccp.c chap.c gen16.c genmd5.c lcp.c md5.c md5step.c pap.c pktrx.c pkttx.c ppp.c pppfsm.c pppglob.c ppphdlc.c
  group MQX_SRC/rtcs/source/snmp
    ../MQX_SRC/rtcs/source/snmp/: 1213.c mib.c mqxmib.c snmp.c trap_receivers.c traps.c
  group MQX_SRC/rtcs/source/tcpip
    ../MQX_SRC/rtcs/source/tcpip/: bootcomm.c bootinit.c bootp.c checksum.c checksum6.c dhcpclnt.c dhcputil.c icmp.c igmp.c igmputil.c ip.c ip_if.c ip_reasm.c iplocal.c ipradix.c iproute.c iptunnel.c iputil.c rip.c route.c rtcspcb.c tcp.c tcp_buf.c tcp_clos.c tcp_rcv.c tcp_send.c tcp_timer.c tcpip.c ticker.c udp.c
  group MQX_SRC/shell/source/mfs
    ../MQX_SRC/shell/source/mfs/: sh_cache.c sh_cd.c sh_compare.c sh_copy.c sh_create.c sh_del.c sh_df.c sh_di.c sh_dir.c sh_dirent.c sh_disect.c sh_flush.c sh_format.c sh_mkdir.c sh_pwd.c sh_read.c sh_readtest.c sh_rename.c sh_rmdir.c sh_type.c sh_write.c sh_writetest.c
  group MQX_SRC/shell/source/mqx
    ../MQX_SRC/shell/source/mqx/: sh_abort.c sh_kill.c sh_pause.c sh_tad.c
  group MQX_SRC/shell/source/rtcs
    ../MQX_SRC/shell/source/rtcs/: sh_arpdisp.c sh_clock.c sh_echo.c sh_echosrv.c sh_enet.c sh_ftpc.c sh_ftpsrv.c sh_gate.c sh_getname.c sh_getroute.c sh_ghbn.c sh_ipconfig.c sh_iwconfig.c sh_llmnrsrv.c sh_nat.c sh_nstat.c sh_ping.c sh_ppp.c sh_rtcs.c sh_sendto.c sh_smtp.c sh_snmpd.c sh_telnetcln.c sh_telnetsrv.c sh_tftpcln.c sh_tftpsrv.c
  group MQX_SRC/shell/source/shell
    ../MQX_SRC/shell/source/shell/: sh_cmdlist.c sh_exit.c sh_help.c sh_sh.c sh_util.c shell.c
  group MQX_SRC/usb/adapter
    ../MQX_SRC/usb/adapter/: adapter_mqx.c
  group MQX_SRC/usb/device
    ../MQX_SRC/usb/device/: usb_dev_bsp.c
  group MQX_SRC/usb/device/classes/audio
    ../MQX_SRC/usb/device/classes/audio/: usb_audio.c
  group MQX_SRC/usb/device/classes/cdc
    ../MQX_SRC/usb/device/classes/cdc/: usb_cdc.c usb_cdc_pstn.c
  group MQX_SRC/usb/device/classes/common
    ../MQX_SRC/usb/device/classes/common/: usb_class.c
  group MQX_SRC/usb/device/classes/composite
    ../MQX_SRC/usb/device/classes/composite/: usb_composite.c
  group MQX_SRC/usb/device/classes/hid
    ../MQX_SRC/usb/device/classes/hid/: usb_hid.c
  group MQX_SRC/usb/device/classes/msd
    ../MQX_SRC/usb/device/classes/msd/: usb_msc.c usb_msc_scsi.c
  group MQX_SRC/usb/device/classes/phdc
    ../MQX_SRC/usb/device/classes/phdc/: usb_phdc.c
  group MQX_SRC/usb/device/controller
    ../MQX_SRC/usb/device/controller/: usb_dev.c usb_framework.c
  group MQX_SRC/usb/device/controller/ehci
    ../MQX_SRC/usb/device/controller/ehci/: device_ehci_interface.c ehci_dev_main.c
  group MQX_SRC/usb/device/controller/khci
    ../MQX_SRC/usb/device/controller/khci/: device_khci_interface.c khci_dev.c
